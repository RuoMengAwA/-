# Keil uVision project STM32F10x.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x +hex
  c flags: uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Library\inc;.\Startup;.\User;.\Hardware;.\Basic
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Library
    ./Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c sysInfo.h
  group Basic
    ./Basic/: ADC_DMA.c ADC_DMA.h USART.c USART.h TimingAndDelay.c TimingAndDelay.h UserConf.c UserConf.h cJSON.c cJSON.h MemoryManage.c MemoryManage.h sysInit.c sysInit.h Debug.c Debug.h
  group Hardware
    ./Hardware/: MQ-3.c MQ-3.h HC-06.c HC-06.h DHT11.c DHT11.h
